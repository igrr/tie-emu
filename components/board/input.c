#include <stdatomic.h>
#include "input.h"

#define QLEN 256

static input_event_t s_q[QLEN];
static atomic_uint s_head, s_tail;

bool input_push(const input_event_t *ev)
{
    unsigned t = atomic_load_explicit(&s_tail, memory_order_relaxed);
    if (t - atomic_load_explicit(&s_head, memory_order_acquire) >= QLEN) {
        return false;
    }
    s_q[t % QLEN] = *ev;
    atomic_store_explicit(&s_tail, t + 1, memory_order_release);
    return true;
}

/* USB HID keyboard usage -> PC/XT scancode set 1; 0xE0xx is an extended key */
static const uint16_t s_hid_to_set1[256] = {
    [0x04] = 0x1e, [0x05] = 0x30, [0x06] = 0x2e, [0x07] = 0x20, [0x08] = 0x12, [0x09] = 0x21, [0x0a] = 0x22,
    [0x0b] = 0x23, [0x0c] = 0x17, [0x0d] = 0x24, [0x0e] = 0x25, [0x0f] = 0x26, [0x10] = 0x32, [0x11] = 0x31,
    [0x12] = 0x18, [0x13] = 0x19, [0x14] = 0x10, [0x15] = 0x13, [0x16] = 0x1f, [0x17] = 0x14, [0x18] = 0x16,
    [0x19] = 0x2f, [0x1a] = 0x11, [0x1b] = 0x2d, [0x1c] = 0x15, [0x1d] = 0x2c,
    [0x1e] = 0x02, [0x1f] = 0x03, [0x20] = 0x04, [0x21] = 0x05, [0x22] = 0x06, [0x23] = 0x07, [0x24] = 0x08,
    [0x25] = 0x09, [0x26] = 0x0a, [0x27] = 0x0b,
    [0x28] = 0x1c, [0x29] = 0x01, [0x2a] = 0x0e, [0x2b] = 0x0f, [0x2c] = 0x39, [0x2d] = 0x0c, [0x2e] = 0x0d,
    [0x2f] = 0x1a, [0x30] = 0x1b, [0x31] = 0x2b, [0x32] = 0x2b, [0x33] = 0x27, [0x34] = 0x28, [0x35] = 0x29,
    [0x36] = 0x33, [0x37] = 0x34, [0x38] = 0x35, [0x39] = 0x3a,
    [0x3a] = 0x3b, [0x3b] = 0x3c, [0x3c] = 0x3d, [0x3d] = 0x3e, [0x3e] = 0x3f, [0x3f] = 0x40, [0x40] = 0x41,
    [0x41] = 0x42, [0x42] = 0x43, [0x43] = 0x44, [0x44] = 0x57, [0x45] = 0x58,
    [0x46] = 0xe037, [0x47] = 0x46,
    [0x49] = 0xe052, [0x4a] = 0xe047, [0x4b] = 0xe049, [0x4c] = 0xe053, [0x4d] = 0xe04f, [0x4e] = 0xe051,
    [0x4f] = 0xe04d, [0x50] = 0xe04b, [0x51] = 0xe050, [0x52] = 0xe048,
    [0x53] = 0x45, [0x54] = 0xe035, [0x55] = 0x37, [0x56] = 0x4a, [0x57] = 0x4e, [0x58] = 0xe01c,
    [0x59] = 0x4f, [0x5a] = 0x50, [0x5b] = 0x51, [0x5c] = 0x4b, [0x5d] = 0x4c, [0x5e] = 0x4d, [0x5f] = 0x47,
    [0x60] = 0x48, [0x61] = 0x49, [0x62] = 0x52, [0x63] = 0x53, [0x64] = 0x56,
    [0xe0] = 0x1d, [0xe1] = 0x2a, [0xe2] = 0x38, [0xe3] = 0xe05b, [0xe4] = 0xe01d, [0xe5] = 0x36, [0xe6] = 0xe038,
    [0xe7] = 0xe05c,
};

void input_drain(machine_t *m)
{
    unsigned h = atomic_load_explicit(&s_head, memory_order_relaxed);
    unsigned t = atomic_load_explicit(&s_tail, memory_order_acquire);
    for (; h != t; h++) {
        const input_event_t *ev = &s_q[h % QLEN];
        if (ev->type == INPUT_KEY) {
            uint16_t sc = ev->code < 256 ? s_hid_to_set1[ev->code] : 0;
            if (!sc) {
                continue;
            }
            if (sc >> 8) {
                machine_key(m, 0xe0);
            }
            machine_key(m, (uint8_t)(sc & 0x7f) | (ev->down ? 0 : 0x80));
        } else {
            machine_mouse(m, ev->dx, ev->dy, ev->buttons);
        }
    }
    atomic_store_explicit(&s_head, h, memory_order_release);
}
